options:
  parameters:
    author: Wilmar Arcila Castaño
    generate_options: qt_gui
    id: FM_spectrum
    output_language: python
    title: Espectro de FM comercial
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: USRP
  id: parameter
  parameters:
    value: '"serial=315EED6"'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: RF_Center_Freq
    type: intx
    value: '98000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    legend: 'False'
    name: '"Espectro FM"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: USRP
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
