options:
  parameters:
    author: WAC
    copyright: Gita Standard
    generate_options: qt_gui
    id: FM_Tx_Rx
    output_language: python
    title: FM_Tx_Rx
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: 1/(1+audio_rate*75e-6)
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,0,1,2)
    label: Input Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '35'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,1)
    label: RF_Center_Freq
    orient: Qt.Horizontal
    rangeType: int
    start: '88000000'
    step: '50000'
    stop: '108000000'
    value: '94200000'
  states: {}
- name: sine_f
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,1,1,1)
    label: SineWave_Freq
    orient: Qt.Horizontal
    rangeType: int
    start: '100'
    step: '20'
    stop: '1000'
    value: '440'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: audio_rate*10
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: audio_bw
    gain: '1'
    samp_rate: usrp_rate
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: USRP
  id: parameter
  parameters:
    value: '"serial=315EED6"'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '0.1'
    reference: '0.2'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: int(usrp_rate/audio_rate)
    audio_pass: audio_bw
    audio_stop: audio_bw+1000
    chan_rate: usrp_rate
    deviation: delta_F
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: audio_rate
    tau: '75e-6'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: sine_f
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_bw
  id: parameter
  parameters:
    type: intx
    value: '15000'
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    type: intx
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '500'
    max_iter: '500'
    scale: '0.5e-3'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: delta_F
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ue-device/Documents/GNU_Radio_Models/por_si_acaso4.wav
    repeat: 'True'
  states: {state: disabled}
- name: delta_F
  id: parameter
  parameters:
    type: intx
    value: '75000'
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,1-alpha]'
    fftaps: '[alpha]'
    type: ffd
  states: {state: disabled}
- name: iir_filter_xxx_1
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, -0.07914]'
    fftaps: '[4.556, -3.638]'
    type: ffd
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: usrp_rate
    ctrlpanel: 'True'
    fc: fc
    fftsize: '1024'
    grid: 'True'
    gui_hint: (0,1,1,1)
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,0,1,2)
    nconnections: '2'
    size: '1024'
    srate: audio_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,0,1,2)
    size: '2048'
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: usrp_rate
    fc: fc
    fftsize: '2048'
    grid: 'True'
    gui_hint: (0,0,1,1)
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(usrp_rate/audio_rate)
    taps: variable_low_pass_filter_taps_0
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_addr: USRP
    dev_args: '""'
    gain0: '50'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: usrp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc
    dc_offs_enb0: '""'
    dev_addr: USRP
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: usrp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', audio_sink_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_fm_demod_cf_0, '0', analog_agc_xx_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_0, '1']
- [analog_fm_preemph_0, '0', blocks_moving_average_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_xx_0_0, '0']
- [audio_source_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_magphase_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_xx_0_0, '0', analog_fm_preemph_0, '0']
- [blocks_multiply_const_xx_0_0, '0', iir_filter_xxx_1, '0']
- [blocks_multiply_const_xx_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_xx_0_0, '0']
- [iir_filter_xxx_1, '0', blocks_moving_average_xx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_magphase_to_complex_0, '1']
- [uhd_usrp_source_0, '0', analog_fm_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
