options:
  parameters:
    author: w.arcila.castaño
    generate_options: qt_gui
    id: vor_demod
    output_language: python
    title: VOR demodulation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '224000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {state: disabled}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '16'
    audio_pass: '40'
    audio_stop: '80'
    chan_rate: '16000'
    deviation: '480'
    gain: '1.0'
    tau: '0'
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1.1e-3'
    gate: 'False'
    ramp: '100'
    threshold: '-15'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '9960'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '90'
    offset: '0'
    phase: '0'
    samp_rate: '1000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1000'
    high_cutoff_freq: '1300'
    low_cutoff_freq: '900'
    samp_rate: '16000'
    type: fir_filter_ccf
    width: '200'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '10'
    high_cutoff_freq: '1200'
    low_cutoff_freq: '1000'
    samp_rate: '16000'
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/n_gaviria/GRC/VOR/VOR_MRN_224Ksps.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: center_freq
  id: parameter
  parameters:
    label: RF_Center_Freq
    type: intx
    value: '113000000'
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '16'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: dc_blocker_xx_0_0_0
  id: dc_blocker_xx
  parameters:
    length: '16'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: dc_blocker_xx_0_0_0_0
  id: dc_blocker_xx
  parameters:
    length: '10'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: '2'
    gain: '1'
    samp_rate: '1000'
    type: fir_filter_fff
    width: '15'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '65'
    decim: '2'
    gain: '30000'
    samp_rate: '1000'
    type: fir_filter_ccf
    width: '15'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_2_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '70'
    decim: '1'
    gain: '2'
    samp_rate: '500'
    type: fir_filter_ccf
    width: '20'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '16000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: (2,0,1,1)
    label1: Full band
    name: '"VOR Identification Signal (Morse)"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-70'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '500'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: (2,0,1,1)
    label1: Full band
    legend: 'False'
    name: '"VOR MRN reference"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-120'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '500'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: (2,1,1,1)
    label1: Full band
    legend: 'False'
    name: '"VOR MRN radial"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-120'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '1000'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: (2,1,1,1)
    label1: Full band
    legend: 'False'
    name: '"VOR MRN Radial"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,1,2)
    label1: Reference
    label2: Radial
    legend: 'False'
    name: '"VOR MRN Signals"'
    nconnections: '2'
    size: '250'
    srate: '500'
    type: float
    ymax: '1.1'
    ymin: '-1.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: (0,0,1,1)
    name: '"VOR Identification Signal (Morse)"'
    size: 20*16000
    srate: '16000'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,1,2)
    label1: Reference
    legend: 'False'
    name: '"VOR MRN Signals"'
    size: '500'
    srate: '500'
    type: float
    ymax: '1.1'
    ymin: '-1.1'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '16000'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: (1,0,1,1)
    int_max: '-42'
    int_min: '-52'
    name: '"VOR Identification Signal (Morse)"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '14'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '14'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '224'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', low_pass_filter_0_2, '0']
- [analog_pwr_squelch_xx_0, '0', audio_sink_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [band_pass_filter_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_complex_to_real_0, '0', band_pass_filter_0_0, '0']
- [blocks_complex_to_real_0_0, '0', dc_blocker_xx_0_0_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_2_0, '0']
- [dc_blocker_xx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [dc_blocker_xx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [dc_blocker_xx_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [dc_blocker_xx_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [dc_blocker_xx_0_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [dc_blocker_xx_0_0_0_0, '0', analog_agc2_xx_0, '0']
- [low_pass_filter_0_2, '0', dc_blocker_xx_0_0, '0']
- [low_pass_filter_0_2_0, '0', low_pass_filter_0_2_0_0, '0']
- [low_pass_filter_0_2_0_0, '0', blocks_complex_to_real_0_0, '0']
- [low_pass_filter_0_2_0_0, '0', dc_blocker_xx_0_0_0_0, '0']
- [rational_resampler_xxx_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_0_0_1, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0_0_1, '0', low_pass_filter_0_2_0, '0']
- [rational_resampler_xxx_0_0_1, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0_0, '0', rational_resampler_xxx_0_0_1, '0']

metadata:
  file_format: 1
