options:
  parameters:
    author: w.arcila.castaño
    generate_options: qt_gui
    id: vor_spectrum
    output_language: python
    title: VOR Spectrum
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '224000'
  states: {}
- name: USRP
  id: parameter
  parameters:
    value: '"serial=315EED6"'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/n_gaviria/GRC/VOR_MRN_224Ksps.iq
    type: complex
  states: {state: disabled}
- name: center_freq
  id: parameter
  parameters:
    label: RF_Center_Freq
    type: intx
    value: '113672000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: (1,0,1,1)
    label1: Full band
    name: '"VOR MRN"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-70'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,1,1)
    name: '"VOR Baseband Signal"'
    size: '16000'
    srate: samp_rate
    type: complex
    ymax: '0.0015'
    ymin: '-0.0015'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: (2,0,1,1)
    int_max: '-70'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: USRP
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
