options:
  parameters:
    author: WAC
    copyright: Gita Standard
    generate_options: qt_gui
    id: AM_Tx_Rx
    output_language: python
    title: AM_Tx_Rx
  states: {}

blocks:
- name: ModIndex_id
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,1)
    label: Mod. Index
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: carrier_id
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: (2,1,1,1)
    label: Carrier
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: audio_rate*10
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: audio_bw
    gain: '1'
    samp_rate: audio_rate
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: variable_low_pass_filter_taps_1
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: audio_bw
    gain: '1.0'
    samp_rate: usrp_rate
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: USRP
  id: parameter
  parameters:
    label: serial=315EEDB
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '100e-3'
    reference: '0.2'
    type: float
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: audio_bw
  id: parameter
  parameters:
    type: intx
    value: '10000'
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: carrier_id
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: ModIndex_id
    type: float
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ue-device/Documents/GNU_Radio_Models/por_si_acaso4.wav
    repeat: 'True'
  states: {}
- name: fc
  id: parameter
  parameters:
    type: eng_float
    value: 500e6
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '10'
    samp_rate: audio_rate
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: audio_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: (0,0,2,2)
    name: Complex Tx/Rx
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: audio_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: (3,0,2,2)
    name: Float Rx
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (5,0,2,2)
    label1: No Gain
    label2: AGC
    nconnections: '2'
    size: '1024'
    srate: audio_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (3,0,2,2)
    name: '"Tx time"'
    size: '1024'
    srate: 44.1e3
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(usrp_rate/audio_rate)
    taps: variable_low_pass_filter_taps_1
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(usrp_rate/audio_rate)
    interp: '1'
    taps: variable_low_pass_filter_taps_0
    type: ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_addr: USRP
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: usrp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc
    dc_offs_enb0: '""'
    dev_addr: USRP
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: usrp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_fm_deemph_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [analog_fm_deemph_0, '0', blocks_null_sink_0, '0']
- [analog_fm_deemph_0, '0', qtgui_time_sink_x_0, '1']
- [analog_fm_preemph_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_real_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_xx_1, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', analog_fm_preemph_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_xx_1, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0_0, '1']

metadata:
  file_format: 1
