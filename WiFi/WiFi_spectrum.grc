options:
  parameters:
    author: Wilmar Arcila Castaño
    generate_options: qt_gui
    id: WiFi_spectrum
    output_language: python
    title: Espectro WiFi
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0,1,2)
    label: RF_Center_Freq
    orient: Qt.Horizontal
    rangeType: int
    start: '2402000000'
    step: '10000000'
    stop: '2500000000'
    value: '2412000000'
  states: {state: disabled}
- name: fc
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (1,0,1,2)
    label: channel_chooser
    label0: LOW
    label1: MED
    label2: HIGH
    num_opts: '3'
    option0: '2414000000'
    option1: '2440000000'
    option2: '2464000000'
    orient: Qt.QHBoxLayout
    type: int
    value: '2414000000'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '28000000'
  states: {}
- name: USRP
  id: parameter
  parameters:
    value: '"serial=315EED6"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: fc
    fftsize: '2048'
    grid: 'True'
    gui_hint: (0,0,1,1)
    legend: 'False'
    name: '"Espectro WiFi"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '2048'
    grid: 'True'
    gui_hint: (0,1,1,1)
    int_max: '-40'
    int_min: '-120'
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: fc
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: USRP
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
